# Keil uVision project 1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: 1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\LIB;.\User;.\LIB\src;.\LIB\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Sturtup
    ./LIB/: startup_stm32f030xc.s
  group User
    ./User/: main.c DMA_func.c effects.c init.c PCB705.h stripLibrary.c MyEffect.c
    ./LIB/: system_stm32f0xx.c
  group CMSIS
    ./LIB/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_tim.c stm32f0xx_iwdg.c stm32f0xx_dma.c stm32f0xx_adc.c stm32f0xx_crc.c
  group StdPeriph
    ./LIB/: stm32f0xx.h stm32f0xx_conf.h
  group H
    ./LIB/: core_cm0.h core_cmFunc.h core_cmInstr.h
